options:
  parameters:
    author: Deepwave Digital, Inc
    category: Custom
    description: Example for Wavelearner Inference Block
    generate_options: no_gui
    id: classifier_test
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: input_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: float
    vlen: output_len*batch_size
  states: {}
- name: buffer0
  id: blocks_stream_to_vector
  parameters:
    num_items: batch_size*input_len
    type: complex
  states: {}
- name: inference
  id: wavelearner_inference
  parameters:
    batch_size: batch_size
    input_type: complex
    input_vlen: input_len*batch_size
    output_vlen: output_len*batch_size
    plan_filepath: saved_model.plan
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: ''
    ant1: ''
    balance0: '0'
    center_freq0: frequency
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'True'
    dc_offset_auto_mode1: 'False'
    dev: '"device=SoapyAIRT"'
    fine_tune0: 'False'
    fine_tune1: 'False'
    gain_auto_mode0: 'True'
    gain_auto_mode1: 'False'
    lna_gain0: '0'
    lna_gain1: '0'
    mix_gain0: '0'
    mix_gain1: '0'
    overall_gain0: '0'
    overall_gain1: '0'
    pga_gain0: '0'
    pga_gain1: '0'
    samp_rate: samp_rate
    tuner_gain0: '0'
    tuner_gain1: '0'
    type: fc32
    vga_gain0: '0'
    vga_gain1: '0'
  states: {}

connections:
- [buffer0, '0', inference, '0']
- [inference, '0', blocks_file_sink_0, '0']
- [soapy_source_0, '0', buffer0, '0']

metadata:
  file_format: 1
