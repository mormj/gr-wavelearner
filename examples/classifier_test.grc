options:
  parameters:
    author: Deepwave Digital, Inc
    category: Custom
    description: Example for Wavelearner Inference Block
    generate_options: qt_gui
    id: classifier_test
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '32'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: input_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 31.25e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: float
    vlen: output_len*batch_size
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /share/gnuradio/benchmark-dnn/RML2016.10a.train.fc32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: batch_size
    type: float
    vlen: output_len
  states: {}
- name: buffer0
  id: blocks_stream_to_vector
  parameters:
    num_items: batch_size*input_len
    type: complex
  states: {}
- name: inference
  id: wavelearner_inference
  parameters:
    batch_size: batch_size
    input_type: complex
    input_vlen: input_len*batch_size
    output_vlen: output_len*batch_size
    plan_filepath: /share/gnuradio/benchmark-dnn/cnnvt2.trt
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: output_len
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: ''
    ant1: ''
    balance0: '0'
    center_freq0: frequency
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'True'
    dc_offset_auto_mode1: 'False'
    dev: '"device=SoapyAIRT"'
    fine_tune0: 'False'
    fine_tune1: 'False'
    gain_auto_mode0: 'True'
    gain_auto_mode1: 'False'
    lna_gain0: '0'
    lna_gain1: '0'
    mix_gain0: '0'
    mix_gain1: '0'
    overall_gain0: '0'
    overall_gain1: '0'
    pga_gain0: '0'
    pga_gain1: '0'
    samp_rate: samp_rate
    tuner_gain0: '0'
    tuner_gain1: '0'
    type: fc32
    vga_gain0: '0'
    vga_gain1: '0'
  states: {state: disabled}
- name: wavelearner_terminal_sink_0
  id: wavelearner_terminal_sink
  parameters:
    batch_size: batch_size
    input_vlen: output_len*batch_size
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', buffer0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_vector_sink_f_0, '0']
- [buffer0, '0', inference, '0']
- [inference, '0', blocks_file_sink_0, '0']
- [inference, '0', blocks_vector_to_stream_0, '0']
- [inference, '0', wavelearner_terminal_sink_0, '0']
- [soapy_source_0, '0', buffer0, '0']

metadata:
  file_format: 1
