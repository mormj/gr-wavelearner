options:
  parameters:
    author: Deepwave Digital
    category: Custom
    generate_options: qt_gui
    id: cuda_fft_demo
    output_language: python
    title: AIR-T Example
  states: {}

blocks:
- name: fft_batch_size
  id: variable
  parameters:
    value: '128'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 3.1e9
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-300000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {state: bypassed}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_batch_size*nfft
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_batch_size
    type: complex
    vlen: nfft
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"cuFFT"'
    showports: 'True'
    update_time: '0.05'
    vlen: nfft
    x_axis_label: '"Normalized Frequency"'
    x_start: '-0.5'
    x_step: 1.0/float(nfft)
    y_axis_label: '"PSD (dB)"'
    ymin: '-60'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: ''
    ant1: ''
    balance0: '0'
    center_freq0: frequency
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'True'
    dc_offset_auto_mode1: 'False'
    dev: '"device=SoapyAIRT"'
    fine_tune0: 'False'
    fine_tune1: 'False'
    gain_auto_mode0: 'True'
    gain_auto_mode1: 'False'
    lna_gain0: '0'
    lna_gain1: '0'
    mix_gain0: '0'
    mix_gain1: '0'
    overall_gain0: '0'
    overall_gain1: '0'
    pga_gain0: '0'
    pga_gain1: '0'
    samp_rate: samp_rate
    tuner_gain0: '0'
    tuner_gain1: '0'
    type: fc32
    vga_gain0: '0'
    vga_gain1: '0'
  states: {state: disabled}
- name: wavelearner_fft_1
  id: wavelearner_fft
  parameters:
    direction: 'True'
    fft_size: nfft
    vlen: fft_batch_size*nfft
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', wavelearner_fft_1, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_source_0, '0', blocks_stream_to_vector_0, '0']
- [wavelearner_fft_1, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
